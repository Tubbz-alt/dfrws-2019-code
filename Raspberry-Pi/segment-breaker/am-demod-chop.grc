options:
  parameters:
    generate_options: qt_gui
    id: am_demod_chop
    output_language: python
  states: {}

blocks:
- name: capture_freq
  id: variable
  parameters:
    value: 1.0001e9
  states: {}
- name: cpu_freq
  id: variable
  parameters:
    value: capture_freq + cpu_offset
  states: {}
- name: cpu_offset
  id: variable
  parameters:
    value: '-72e3'
  states: {}
- name: firdes_tap_low_reader
  id: variable
  parameters:
    value: firdes.low_pass(1, samp_rate, 300000, 10000, firdes.WIN_HAMMING, 6.76)
  states: {}
- name: low_sideband_freq
  id: variable
  parameters:
    value: cpu_freq - sideband_offset
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e5
  states: {}
- name: sideband_offset
  id: variable
  parameters:
    value: 257e3
  states: {}
- name: up_sideband_freq
  id: variable
  parameters:
    value: cpu_freq + sideband_offset
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-1.1'
    type: float
  states: {state: disabled}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/orville/Documents/tech/projects/cybersecurity/rf/kudu/easypass_captures/mine/oh_day1/first/during/reader/grc.bytes
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ../data/1block/2/0-chopped.dat
    length: '20000'
    offset: '10000'
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '100'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate/200
    type: complex
  states: {state: disabled}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_1
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)
    omega_relative_limit: '0.1'
    type: float
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: cpu_offset
    decim: '1'
    samp_rate: samp_rate
    taps: firdes_tap_low_reader
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: capture_freq
    fftsize: '1024'
    showports: 'True'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: cpu_freq
    fftsize: '1024'
    showports: 'True'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: ''
    size: '20000'
    srate: samp_rate
    tr_delay: '0.0010'
    tr_level: '3.5'
    type: float
    update_time: '0.01'
    ymax: '1.2'
    ymin: '-1.2'
  states: {}

connections:
- [blocks_add_const_vxx_1, '0', digital_clock_recovery_mm_xx_1, '0']
- [blocks_add_const_vxx_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [blocks_throttle_1, '0', qtgui_freq_sink_x_0, '0']
- [digital_binary_slicer_fb_1, '0', blocks_file_sink_1, '0']
- [digital_clock_recovery_mm_xx_1, '0', digital_binary_slicer_fb_1, '0']
- [digital_clock_recovery_mm_xx_1, '0', qtgui_time_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', blocks_complex_to_mag_1, '0']
- [freq_xlating_fir_filter_xxx_1, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1

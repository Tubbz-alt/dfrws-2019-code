options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: rpi_data_acquisition
    output_language: python
  states: {}

blocks:
- name: capture_freq
  id: variable
  parameters:
    value: 1.0001e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200000'
  states: {}
- name: trigger
  id: variable
  parameters:
    value: '-1'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: trigger
    type: short
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: complex
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: testme
    type: complex
  states: {state: disabled}
- name: blocks_tagged_file_sink_0
  id: blocks_tagged_file_sink
  parameters:
    samp_rate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: capture_freq
    fftsize: '8192'
    name: '"Waterfall Plot"'
    type: complex
    update_time: '0.04'
    wintype: firdes.WIN_HANN
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: '"rtl=0"'
    bb_gain0: '20'
    freq0: capture_freq
    gain0: '40'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_burst_tagger_0, '1']
- [blocks_burst_tagger_0, '0', blocks_tagged_file_sink_0, '0']
- [rtlsdr_source_0, '0', blocks_burst_tagger_0, '0']
- [rtlsdr_source_0, '0', blocks_file_sink_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
